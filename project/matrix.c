/*********************************************************************************************************************

********************************************************************************************************************/

#include "zf_common_headfile.h"
#include "matrix.h"

//====================================================变量声明=======================================================


//====================================================自定义全局变量=================================================


//====================================================自定义静态变量=================================================


//====================================================函数声明======================================================

//-------------------------------------------------------------------------------------------------------------------
// 函数简介        
// 参数说明             
// 返回参数     
// 使用示例     
// 备注信息     
//-------------------------------------------------------------------------------------------------------------------


//-------------------------------------------------------------------------------------------------------------------
// 函数简介     初始化矩阵   
// 参数说明    *m 矩阵结构体指针        rows：行数    cols ：列数      
// 返回参数      
//-------------------------------------------------------------------------------------------------------------------
void mat_init(Matrix *m, int rows, int cols)
{
    m->rows = rows;
    m->cols = cols;
    for(int i=0; i<rows; i++)
        for(int j=0; j<cols; j++)
            m->data[i][j] = 0.0f;
}


 //-------------------------------------------------------------------------------------------------------------------
// 函数简介   给矩阵指定位置 (row, col) 赋值 val      
//-------------------------------------------------------------------------------------------------------------------
void mat_set(Matrix *m, int row, int col, float val)
{
    // 简单越界保护
    if(row >= 0 && row < m->rows && col >=0 && col < m->cols)
    {
        m->data[row][col] = val;
    }
}


//-------------------------------------------------------------------------------------------------------------------
// 函数简介     单位矩阵        
//-------------------------------------------------------------------------------------------------------------------

void mat_eye(Matrix *m)
{
    for(int i=0; i<m->rows; i++)
        for(int j=0; j<m->cols; j++)
            m->data[i][j] = (i==j) ? 1.0f : 0.0f;
}

//-------------------------------------------------------------------------------------------------------------------
// 函数简介     矩阵加法 C = A + B        
//-------------------------------------------------------------------------------------------------------------------
void mat_add(Matrix *C, Matrix *A, Matrix *B)
{
    // 校验维度匹配：A/B行列数必须一致，且C的维度与A/B一致
    if(A->rows != B->rows || A->cols != B->cols || 
       C->rows != A->rows || C->cols != A->cols) {
        return; // 维度不匹配，直接返回
    }
    
    for(int i=0; i<A->rows; i++)
        for(int j=0; j<A->cols; j++)
            C->data[i][j] = A->data[i][j] + B->data[i][j];
}

//-------------------------------------------------------------------------------------------------------------------
// 函数简介     矩阵乘法 C = A * B        
//-------------------------------------------------------------------------------------------------------------------

void mat_mul(Matrix *C, Matrix *A, Matrix *B)
{
    // 校验维度匹配：A的列数=B的行数，且C的行数=A的行数、C的列数=B的列数
    if(A->cols != B->rows || 
       C->rows != A->rows || C->cols != B->cols) {
        return; // 维度不匹配，直接返回
    }
    
    for(int i=0; i<A->rows; i++)
    {
        for(int j=0; j<B->cols; j++)
        {
            float sum = 0;
            for(int k=0; k<A->cols; k++)
                sum += A->data[i][k] * B->data[k][j];
            C->data[i][j] = sum;
        }
    }
}
//-------------------------------------------------------------------------------------------------------------------
// 函数简介     矩阵转置 B = A^T        
//-------------------------------------------------------------------------------------------------------------------


void mat_trans(Matrix *B, Matrix *A)
{
    for(int i=0; i<A->rows; i++)
        for(int j=0; j<A->cols; j++)
            B->data[j][i] = A->data[i][j];
}



// 对角矩阵求逆
void mat_inv_diag(Matrix *B, Matrix *A)
{
    // 仅处理方阵，且对角元素非零
    if(A->rows != A->cols || B->rows != A->rows || B->cols != A->cols) {
        return;
    }
    for(int i=0; i<A->rows; i++)
    {
        for(int j=0; j<A->cols; j++)
        {
            if(i == j)
                B->data[i][j] = 1.0f / A->data[i][j];
            else
                B->data[i][j] = 0;
        }
    }
}

// matrix.c 中新增：通用矩阵求逆（高斯消元法，适配你的矩阵结构体）
// 输入：A[rows×rows] 可逆矩阵；输出：A_inv[rows×rows] 逆矩阵
// 返回：0=失败（奇异矩阵），1=成功
uint8_t mat_inv(Matrix *A_inv, Matrix *A) {
    if(A == NULL || A_inv == NULL || A->rows != A->cols) return 0;
    int n = A->rows;

    // 构造增广矩阵 [A | I]（临时数组，适配MAT_MAX_N）
    float aug[MAT_MAX_N][2*MAT_MAX_N] = {0};
    for(int i=0; i<n; i++) {
        // 左半部分：原矩阵A
        for(int j=0; j<n; j++) {
            aug[i][j] = mat_get(A, i, j);
        }
        // 右半部分：单位矩阵I
        aug[i][i+n] = 1.0f;
    }

    // 高斯消元：行变换为上三角矩阵
    for(int i=0; i<n; i++) {
        // 找主元（避免除以0）
        float pivot = aug[i][i];
        int pivot_row = i;
        for(int j=i; j<n; j++) {
            if(fabsf(aug[j][i]) > fabsf(pivot)) {
                pivot = aug[j][i];
                pivot_row = j;
            }
        }
        if(fabsf(pivot) < 1e-8) return 0; // 奇异矩阵，不可逆

        // 交换主元行和当前行
        if(pivot_row != i) {
            for(int j=0; j<2*n; j++) {
                float temp = aug[i][j];
                aug[i][j] = aug[pivot_row][j];
                aug[pivot_row][j] = temp;
            }
        }

        // 归一化主元行
        float div = aug[i][i];
        for(int j=0; j<2*n; j++) {
            aug[i][j] /= div;
        }

        // 消去其他行的当前列
        for(int j=0; j<n; j++) {
            if(j != i && fabsf(aug[j][i]) > 1e-8) {
                float factor = aug[j][i];
                for(int k=0; k<2*n; k++) {
                    aug[j][k] -= factor * aug[i][k];
                }
            }
        }
    }

    // 提取逆矩阵到A_inv（适配你的矩阵结构体）
    mat_init(A_inv, n, n);
    for(int i=0; i<n; i++) {
        for(int j=0; j<n; j++) {
            mat_set(A_inv, i, j, aug[i][j+n]);
        }
    }
    return 1;
}
//-------------------------------------------------------------------------------------------------------------------
// 函数简介     获取矩阵指定位置的值        
//-------------------------------------------------------------------------------------------------------------------

float mat_get(Matrix *m, int row, int col) {
    if(row >=0 && row < m->rows && col >=0 && col < m->cols) {
        return m->data[row][col];
    }
    return 0.0f;
}


//-------------------------------------------------------------------------------------------------------------------
// 函数简介  矩阵缩放（所有元素 × 系数
// 参数说明  out：输出矩阵（缩放后的结果，可与输入矩阵mat为同一个，实现原地缩放）
//          mat：输入矩阵（待缩放的原矩阵）
//          scale：缩放系数（浮点数，如0.01表示缩小100倍）
// 返回参数  无
// 备注信息  1. 支持原地缩放；2. 防护空指针/维度不匹配/超出MAT_MAX_N范围
//-------------------------------------------------------------------------------------------------------------------
void mat_scale(Matrix *out, Matrix *mat, float scale) {
    // 1. 空指针防护
    if(out == NULL || mat == NULL) {
        return;
    }

    // 2. 维度校验：输出/输入矩阵行列数一致，且不超过MAT_MAX_N
    if(out->rows != mat->rows || out->cols != mat->cols ||
       mat->rows > MAT_MAX_N || mat->cols > MAT_MAX_N ||
       out->rows > MAT_MAX_N || out->cols > MAT_MAX_N) {
        // 调试日志（可选）
        // printf("mat_scale error: dim mismatch or exceed MAT_MAX_N\n");
        return;
    }

    // 3. 核心逻辑：逐元素缩放（适配二维数组）
    for(int row = 0; row < mat->rows; row++) {
        for(int col = 0; col < mat->cols; col++) {
            // 二维数组正确访问方式：行+列双层循环
            out->data[row][col] = mat->data[row][col] * scale;
        }
    }
}

// matrix.c 中新增：矩阵置零（初始化后清空）
void mat_zero(Matrix *m) {
    if(m == NULL) return;
    for(int i=0; i<m->rows; i++) {
        for(int j=0; j<m->cols; j++) {
            m->data[i][j] = 0.0f;
        }
    }
}